## package/ndr-netcfg/Config.in
```kconfig
config BR2_PACKAGE_NDR_NETCFG
	bool "ndr-netcfg"
	help
	  NDR network configuration tool
```
